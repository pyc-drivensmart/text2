# Keil uVision project F1C100S.uvproj, settings and files
target F1C100S (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: F1C100S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\Project\EXEC ..\Project\obj\F1C100S.bin ..\Project\f1c100s.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1081
  c include: ..\Driver\Include;..\Project;..\USR\libpng;..\USR\libz;..\USR\png;..\USR\Lcd;..\USR\ui_data;..\USR\Src
  memory RVCT1: ROM 0x0 size 0x4000
  memory RVCT4: ROM 0x80000000 size 0x10000
  memory RVCT6: RAM 0x4000 size 0x4000
  memory RVCT9: RAM 0x80010000 size 0xffffffff
  scatter file: ..\Script\F1C100S.sct
  link misc: --entry 0x80000000
  group src
    ../Driver/Source/: standalone.c vectors.s sys_start.s
    ../USR/Src/: GT911.h main.h ToMCU.h AC.c AC_PUT.c DD.c fifo.h GT911.c includes.h LCD480Init.c left_side.c left_side_select.c left_side_touch.c main.c main_side.c ToMCU.c top_side.c top_side_select.c top_side_touch.c
  group Libraries
    ../Driver/Source/: sys_clock.c sys_dram.c sys_gpio.c sys_uart.c sys_delay.c sys_ctl.s sys_interrupt.c sys_lcd.c sys_timer.c sys_mmu.c arm32.c sys_cache.c sys_I2C.c sys_IO_I2C.c
  group libpng
    ../USR/libpng/: png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group libz
    ../USR/libz/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group png
    ../USR/png/: Test_png.c
  group Lcd
    ../USR/Lcd/: sys_lcd_gui_argb32.c sys_virtual_gui_argb32.c ui_def.h ui_func.c sys_ui_pro.c sys_ui_pro.h ctrl_status.c sys_ui_pro_keyboard.h sys_ui_pro_keyboard.c ui_func_keyboard.c sys_ui_pro_dialog_code.h sys_ui_pro_dialog_code.c sys_ui_pro_dialog_info.h sys_ui_pro_dialog_info.c ui_func_dialog_code.c ui_func_dialog_info.c sys_ui_pro_dialog_msg.c sys_ui_pro_dialog_msg.h ui_func_dialog_msg.c
    ../USR/ui_data/: ui_data.c
    ../USR/Src/: sys_ui_pro_dialog_test.c sys_ui_pro_dialog_test.h
  group Left_System
    ../USR/Lcd/: sys_ui_pro_system.c sys_ui_pro_system.h ui_func_system.c ui_func_system_alarm.c sys_ui_pro_system_alarm.h sys_ui_pro_system_alarm.c sys_ui_pro_system_accessories.c sys_ui_pro_system_accessories.h ui_func_system_accessories.c sys_ui_pro_system_info.c sys_ui_pro_system_info.h ui_func_system_info.c
  group Left_Home
    ../USR/Lcd/: ui_func_home.c sys_ui_pro_home.c sys_ui_pro_home.h
  group Left_Power
    ../USR/Lcd/: ui_func_power.c sys_ui_pro_power.c sys_ui_pro_power.h ui_func_power_set.c sys_ui_pro_power_set.c sys_ui_pro_power_set.h sys_ui_pro_power_system.c sys_ui_pro_power_system.h sys_ui_pro_power_alarm.c sys_ui_pro_power_alarm.h ui_func_power_alarm.c
  group Left_Lights
    ../USR/Lcd/: ui_func_lights.c sys_ui_pro_lights.c sys_ui_pro_lights.h ui_func_dialog_lights.c sys_ui_pro_dialog_lights.c sys_ui_pro_dialog_lights.h ui_func_dialog_lights_ch.c sys_ui_pro_dialog_lights_ch.c sys_ui_pro_dialog_lights_ch.h
  group Left_Loads
    ../USR/Lcd/: ui_func_loads.c sys_ui_pro_loads.c sys_ui_pro_loads.h ui_func_dialog_loads.c sys_ui_pro_dialog_loads.c sys_ui_pro_dialog_loads.h ui_func_dialog_loads_ch.c sys_ui_pro_dialog_loads_ch.c sys_ui_pro_dialog_loads_ch.h sys_ui_pro_loads_motors.c sys_ui_pro_loads_motors.h ui_func_loads_motors.c sys_ui_pro_dialog_motors.h sys_ui_pro_dialog_motors.c ui_func_dialog_motors.c
  group Left_Tanks
    ../USR/Lcd/: sys_ui_pro_tanks.c sys_ui_pro_tanks.h ui_func_tanks.c ui_func_tanks_set.c sys_ui_pro_tanks_set.c sys_ui_pro_tanks_set.h
  group MyFont
    ../USR/Lcd/: myFont24_4bit.c myFont24_4bit_bold.c myFont8_4bit_bold.c myFont8_4bit.c myFont32_4bit.c myFont48_4bit.c myFont48_4bit_bold.c myFont32_4bit_bold.c myFont16_4bit_bold.c myFont16_4bit.c
    ../USR/Src/: font.c font.h
  group Column_Home
    ../USR/Lcd/: sys_ui_pro_column_home_5.c sys_ui_pro_column_home_5.h ui_func_column_home_5.c
  group Column_power
    ../USR/Lcd/: sys_ui_pro_column_power_5.c sys_ui_pro_column_power_5.h ui_func_column_power_5.c
  group Column_alarm
    ../USR/Lcd/: ui_func_column_alarm_5.c sys_ui_pro_column_alarm_5.h sys_ui_pro_column_alarm_5.c
  group Column_tanks
    ../USR/Lcd/: ui_func_column_tank_5.c sys_ui_pro_column_tank_5.c sys_ui_pro_column_tank_5.h
  group Column_setup
    ../USR/Lcd/: sys_ui_pro_column_setup_5.c sys_ui_pro_column_setup_5.h ui_func_column_setup_5.c
  group Auxiliary_functions
    ../USR/Lcd/: sys_ui_pro_auxilary_keyboard.c sys_ui_pro_auxilary_keyboard.h ui_func_auxilary_keyboard.c
  group page1_light
    ../USR/Lcd/: sys_ui_light.c sys_ui_light.h ui_fun_light.c
  group page2_Elevator
    ../USR/Lcd/: sys_ui_elevator.c sys_ui_elevator.h ui_fun_elevator.c
  group page6_Setup
    ../USR/Lcd/: sys_ui_setup.c sys_ui_setup.h ui_setup_fun.c
  group page3_RGB
    ../USR/Lcd/: sys_ui_rgb.c sys_ui_rgb.h ui_rgb_fun.c
  group page5_AC
    ../USR/Lcd/: sys_ui_ac.c sys_ui_ac.h uiu_ac_fun.c
  group page4_Diese_heater
    ../USR/Lcd/: sys_ui_diese_heater.c sys_ui_diese_heater.h ui_diese_heater_fun.c
  group page_warning_dialog
    ../USR/Lcd/: sys_ui_warning_dialog.c sys_ui_warning_dialog.h ui_warning_dialog_fun.c
